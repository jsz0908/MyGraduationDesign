# Keil uVision project biyesheji.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: biyesheji +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver;.\sys
  group user
    ./: main.c
  group driver
    ./driver/: hx711.c i2c.c lcd1602_i2c.c key.c eeprom.c led.c
  group sys
    ./sys/: timer.c delay.c
